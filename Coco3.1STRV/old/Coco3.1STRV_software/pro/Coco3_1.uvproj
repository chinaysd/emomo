# Keil uVision project Coco3_1.uvproj, settings and files
target Coco3_1 (MCS-51)
  device: SC92F8371 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x7F) CLOCK(24000000)
  output: Coco3_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib;..\user;..\bsp;..\Time_Out
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC92F837X_C.H
  group bsp
    ../bsp/: bsp_key.c bsp_led.c bsp_watchdog.c bsp_interrupt.c bsp_timer.c bsp_uart1.c
  group TimeOut
    ../Time_Out/: TimeOut.c
