# IAR project Coco3_1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: F:\共享文件\Coco3.1\Coco3_1_sorfware\bsp\led; F:\共享文件\Coco3.1\Coco3_1_sorfware\lib\inc; F:\共享文件\Coco3.1\Coco3_1_sorfware\user; F:\共享文件\Coco3.1\Coco3_1_sorfware\bsp\clk; F:\共享文件\Coco3.1\Coco3_1_sorfware\bsp\watch_dog; F:\共享文件\Coco3.1\Coco3_1_sorfware\bsp\interrupt; F:\共享文件\Coco3.1\Coco3_1_sorfware\bsp\timer; F:\共享文件\Coco3.1\Coco3_1_sorfware\bsp\pushrod; F:\共享文件\Coco3.1\Coco3_1_sorfware\bsp\uart; C:\Users\Administrator\Desktop\Coco3_1_sorfware\bsp\key; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\clk; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\interrupt; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\key; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\led; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\pushrod; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\timer; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\uart; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\bsp\watch_dog; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\lib\inc; F:\共享文件\Coco3.1\Coco3.1\Coco3_1_slave\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Coco3_1.srec
  ILINK.IlinkOutputFile: Coco3_1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../bsp/clk/: bsp_clk.c
    ../bsp/key/: bsp_key.c
    ../bsp/led/: bsp_led.c
    ../bsp/pushrod/: bsp_pushrod.c
    ../bsp/timer/: bsp_timer.c TimeOut.c
    ../bsp/uart/: bsp_uart.c
    ../bsp/interrupt/: interrupt_enable.c
    ../bsp/watch_dog/: watchdog.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim4.c stm8s_uart1.c
  group user
    ../user/: main.c stm8s_it.c system.c
