# Keil uVision project Coco3_1.uvproj, settings and files
target Coco3_1 (MCS-51)
  device: SC92F8371 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x7F) CLOCK(24000000)
  output: Coco3_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user;..\bsp\key
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: data_type.h SC92F837X_C.H
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c bsp_uart.c bsp_pushrod_direction.c voice_data.c
    ../bsp/key/: key.c key_port.c
  group TimeOut
    ../TimeOut/: TimeOut.c
