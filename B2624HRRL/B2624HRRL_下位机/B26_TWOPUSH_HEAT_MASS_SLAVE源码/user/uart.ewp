# IAR project uart.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\lib\inc; ..\lib\src; ..\user; ..\drive; C:\Users\Administrator\Desktop\B26SRR\下位机（B26S24HR_12.23）\下位机\lib\inc; C:\Users\Administrator\Desktop\B26SRR\下位机（B26S24HR_12.23）\下位机\drive; C:\Users\Administrator\Desktop\B26SRR\下位机（B26S24HR_12.23）\下位机\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: uart.s19
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group drive
    ../drive/: heat.c key.c led.c mass.c push.c system.c tim1.c TimeOut.c uart.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim4.c stm8s_uart1.c
  group user
    ./: main.c stm8s_it.c
