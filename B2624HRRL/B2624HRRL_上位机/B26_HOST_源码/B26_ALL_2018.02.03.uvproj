# Keil uVision project B26_ALL_2018.02.03.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC93F8332 SC93Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0x3FF) CLOCK(24000000)
  output: B26_ALL_2018.02.03 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\H;.\lib
  group Source Group 1
    ./: STARTUP.A51
    ./C/: main.c UART.C INIT.C
    ./lib/: S_TouchKeyCFG.C SC93F8XXX_HighSensitive_Lib_T1_V0.0.2.LIB
