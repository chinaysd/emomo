# Keil uVision project Remo2C1.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC91F831 SC91Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16000000)
  output: Remo2C1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c key.c init.c command.c
    ./lib/: S_TouchKeyCFG.C SC91F832_LIB_T1_V3.0.0.LIB
