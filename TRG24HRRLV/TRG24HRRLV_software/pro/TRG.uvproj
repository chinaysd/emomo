# Keil uVision project TRG.uvproj, settings and files
target TRG (MCS-51)
  device: SC92F7321 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: TRG24HRRLV +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp\key;..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: data_type.h SC92F732X_C.H
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c bsp_usrt.c bsp_test.c bsp_voice.c
    ../bsp/key/: key.c key_port.c
  group TimeOut
    ../TimeOut/: TimeOut.c
